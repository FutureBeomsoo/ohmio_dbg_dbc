VERSION "1-1_Chassis_CAN_Message_Name_BO_Draft"

NS_:
    CM_

BS_: 500000

BU_: Vector__XXX

BO_ 16 ErrorLocalisation: 8 Vector__XXX
CM_ BO_ 16 "Signal reference struct: ErrorLocalisation_t; source header: dbc_CAN.h; source line: 118; original CAN ID: 0x10";

BO_ 17 ErrorDriveController: 8 Vector__XXX
CM_ BO_ 17 "Signal reference struct: ErrorDriveController_t; source header: dbc_CAN.h; source line: 1240; original CAN ID: 0x11";

BO_ 18 ErrorFrontSteering: 8 Vector__XXX
CM_ BO_ 18 "Signal reference struct: ErrorSteering_t; source header: dbc_CAN.h; source line: 3765; original CAN ID: 0x12";

BO_ 19 ErrorRearSteering: 8 Vector__XXX
CM_ BO_ 19 "Signal reference struct: ErrorSteering_t; source header: dbc_CAN.h; source line: 3766; original CAN ID: 0x13";

BO_ 20 ManualError: 8 Vector__XXX
CM_ BO_ 20 "Signal reference struct: ErrorManual_t; source header: dbc_CAN.h; source line: 3816; original CAN ID: 0x14";

BO_ 21 ErrorFusion: 8 Vector__XXX
CM_ BO_ 21 "Signal reference struct: ErrorFusion_t; source header: dbc_CAN.h; source line: 2695; original CAN ID: 0x15";

BO_ 22 ErrorBlackBox: 8 Vector__XXX
CM_ BO_ 22 "Signal reference struct: ErrorBlackBox_t; source header: dbc_CAN.h; source line: 3863; original CAN ID: 0x16";

BO_ 23 ErrorObstaclePC: 8 Vector__XXX
CM_ BO_ 23 "Signal reference struct: ErrorObstaclePC_t; source header: dbc_CAN.h; source line: 2269; original CAN ID: 0x17";

BO_ 24 ErrorLeftMotor: 8 Vector__XXX
CM_ BO_ 24 "Signal reference struct: ErrorLeftMotor_t; source header: dbc_CAN.h; source line: 3875; original CAN ID: 0x18";

BO_ 26 ErrorEHB: 8 Vector__XXX
CM_ BO_ 26 "Signal reference struct: ErrorEHB_t; source header: dbc_CAN.h; source line: 3897; original CAN ID: 0x1A";

BO_ 27 ErrorEHBT060: 8 Vector__XXX
CM_ BO_ 27 "Signal reference struct: ErrorEHBT060_t; source header: dbc_CAN.h; source line: 3943; original CAN ID: 0x1B";

BO_ 28 EPB1Msg: 8 Vector__XXX
CM_ BO_ 28 "Signal reference struct: EPBErrorMsg_t; source header: dbc_CAN.h; source line: 4018; original CAN ID: 0x1C";

BO_ 29 parkBrake2: 8 Vector__XXX
CM_ BO_ 29 "Signal reference struct: EPBErrorMsg_t; source header: dbc_CAN.h; source line: 4019; original CAN ID: 0x1D";

BO_ 30 frontSignal: 8 Vector__XXX
CM_ BO_ 30 "Signal reference struct: SignalErrorMsg_t; source header: dbc_CAN.h; source line: 4047; original CAN ID: 0x1E";

BO_ 31 rearSignal: 8 Vector__XXX
CM_ BO_ 31 "Signal reference struct: SignalErrorMsg_t; source header: dbc_CAN.h; source line: 4048; original CAN ID: 0x1F";

BO_ 32 ObstacleEmergency: 8 Vector__XXX
CM_ BO_ 32 "Signal reference struct: ObstacleEmergency_t; source header: dbc_CAN.h; source line: 2139; original CAN ID: 0x20";

BO_ 34 ErrorSafetyBoard: 8 Vector__XXX
CM_ BO_ 34 "Signal reference struct: ErrorSafetyBoard_t; source header: dbc_CAN.h; source line: 4072; original CAN ID: 0x22";

BO_ 35 StartupErrorMsg: 8 Vector__XXX
CM_ BO_ 35 "Signal reference struct: StartupErrorMsg_t; source header: dbc_CAN.h; source line: 4099; original CAN ID: 0x23";

BO_ 36 ErrorDriveExt: 8 Vector__XXX
CM_ BO_ 36 "Signal reference struct: ErrorDriveExt_t; source header: dbc_CAN.h; source line: 1582; original CAN ID: 0x24";

BO_ 37 FusError: 8 Vector__XXX
CM_ BO_ 37 "Signal reference struct: FusError_t; source header: dbc_CAN.h; source line: 2765; original CAN ID: 0x25";

BO_ 38 Trans1Error: 8 Vector__XXX
CM_ BO_ 38 "Signal reference struct: ErrorManual_t; source header: dbc_CAN.h; source line: 3817; original CAN ID: 0x26";

BO_ 40 ErrorFooting1: 8 Vector__XXX
CM_ BO_ 40 "Signal reference struct: ErrorFootMsg_t; source header: dbc_CAN.h; source line: 4358; original CAN ID: 0x28";

BO_ 41 ErrorFooting2: 8 Vector__XXX
CM_ BO_ 41 "Signal reference struct: ErrorFootMsg_t; source header: dbc_CAN.h; source line: 4359; original CAN ID: 0x29";

BO_ 42 ErrorSecurity: 8 Vector__XXX
CM_ BO_ 42 "Signal reference struct: ErrorSecurity_t; source header: dbc_CAN.h; source line: 4395; original CAN ID: 0x2A";

BO_ 43 ManagementError: 8 Vector__XXX
CM_ BO_ 43 "Signal reference struct: ManagementError_t; source header: dbc_CAN.h; source line: 630; original CAN ID: 0x2B";

BO_ 45 ErrorNetwork: 8 Vector__XXX
CM_ BO_ 45 "Signal reference struct: ErrorNetwork_t; source header: dbc_CAN.h; source line: 4441; original CAN ID: 0x2D";

BO_ 46 ErrorAccessory1: 8 Vector__XXX
CM_ BO_ 46 "Signal reference struct: ErrorAccessory_t; source header: dbc_CAN.h; source line: 4465; original CAN ID: 0x2E";

BO_ 47 ErrorAccessory2: 8 Vector__XXX
CM_ BO_ 47 "Signal reference struct: ErrorAccessory_t; source header: dbc_CAN.h; source line: 4466; original CAN ID: 0x2F";

BO_ 49 DriveWarningMsg: 8 Vector__XXX
CM_ BO_ 49 "Signal reference struct: DriveWarningMsg_t; source header: dbc_CAN.h; source line: 1322; original CAN ID: 0x31";

BO_ 56 Timepulse_front: 5 Vector__XXX
CM_ BO_ 56 "Signal reference struct: GpsPpsMsg_t; source header: dbc_CAN.h; source line: 12; original CAN ID: 0x38";

BO_ 57 Timepulse_rear: 5 Vector__XXX
CM_ BO_ 57 "Signal reference struct: GpsPpsMsg_t; source header: dbc_CAN.h; source line: 13; original CAN ID: 0x39";

BO_ 58 frontWheelSpeed: 8 Vector__XXX
CM_ BO_ 58 "Signal reference struct: WheelSpeedMsg_t; source header: dbc_CAN.h; source line: 194; original CAN ID: 0x3A";

BO_ 59 rearWheelSpeed: 8 Vector__XXX
CM_ BO_ 59 "Signal reference struct: WheelSpeedMsg_t; source header: dbc_CAN.h; source line: 195; original CAN ID: 0x3B";

BO_ 60 frontWheelCnt: 8 Vector__XXX
CM_ BO_ 60 "Signal reference struct: WheelCountMsg_t; source header: dbc_CAN.h; source line: 226; original CAN ID: 0x3C";

BO_ 61 rearWheelCnt: 8 Vector__XXX
CM_ BO_ 61 "Signal reference struct: WheelCountMsg_t; source header: dbc_CAN.h; source line: 227; original CAN ID: 0x3D";

BO_ 64 ResetReqMsg: 8 Vector__XXX
CM_ BO_ 64 "Signal reference struct: ResetReqMsg_t; source header: dbc_CAN.h; source line: 328; original CAN ID: 0x40";

BO_ 80 ResetLocalisation: 8 Vector__XXX
CM_ BO_ 80 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 725; original CAN ID: 0x50";

BO_ 81 ResetDrive: 8 Vector__XXX
CM_ BO_ 81 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 726; original CAN ID: 0x51";

BO_ 82 ResetSteering1: 8 Vector__XXX
CM_ BO_ 82 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 727; original CAN ID: 0x52";

BO_ 83 ResetSteering2: 8 Vector__XXX
CM_ BO_ 83 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 728; original CAN ID: 0x53";

BO_ 84 ResetManual: 8 Vector__XXX
CM_ BO_ 84 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 729; original CAN ID: 0x54";

BO_ 85 ResetFusion: 8 Vector__XXX
CM_ BO_ 85 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 730; original CAN ID: 0x55";

BO_ 86 ResetBlackBox: 8 Vector__XXX
CM_ BO_ 86 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 731; original CAN ID: 0x56";

BO_ 87 ResetObsPC: 8 Vector__XXX
CM_ BO_ 87 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 732; original CAN ID: 0x57";

BO_ 88 ResetLMotor: 8 Vector__XXX
CM_ BO_ 88 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 733; original CAN ID: 0x58";

BO_ 89 ResetRMotor: 8 Vector__XXX
CM_ BO_ 89 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 734; original CAN ID: 0x59";

BO_ 90 ResetEHB: 8 Vector__XXX
CM_ BO_ 90 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 735; original CAN ID: 0x5A";

BO_ 92 ResetEPB1: 8 Vector__XXX
CM_ BO_ 92 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 736; original CAN ID: 0x5C";

BO_ 93 ResetEPB2: 8 Vector__XXX
CM_ BO_ 93 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 737; original CAN ID: 0x5D";

BO_ 94 ResetSignal1: 8 Vector__XXX
CM_ BO_ 94 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 738; original CAN ID: 0x5E";

BO_ 95 ResetSignal2: 8 Vector__XXX
CM_ BO_ 95 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 739; original CAN ID: 0x5F";

BO_ 96 ResetJoystick: 8 Vector__XXX
CM_ BO_ 96 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 740; original CAN ID: 0x60";

BO_ 98 AtmelResetSafety: 8 Vector__XXX
CM_ BO_ 98 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 775; original CAN ID: 0x62";

BO_ 99 ResetStartup: 8 Vector__XXX
CM_ BO_ 99 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 741; original CAN ID: 0x63";

BO_ 100 AtmelResetLocalisation: 8 Vector__XXX
CM_ BO_ 100 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 776; original CAN ID: 0x64";

BO_ 101 AtmelResetDrive: 8 Vector__XXX
CM_ BO_ 101 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 777; original CAN ID: 0x65";

BO_ 102 AtmelResetManual: 8 Vector__XXX
CM_ BO_ 102 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 778; original CAN ID: 0x66";

BO_ 103 AtmelResetFusion: 8 Vector__XXX
CM_ BO_ 103 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 779; original CAN ID: 0x67";

BO_ 104 ResetFoot1: 8 Vector__XXX
CM_ BO_ 104 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 742; original CAN ID: 0x68";

BO_ 105 ResetFoot2: 8 Vector__XXX
CM_ BO_ 105 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 743; original CAN ID: 0x69";

BO_ 106 ResetSecurity: 5 Vector__XXX
CM_ BO_ 106 "Signal reference struct: ResetSecurity_t; source header: dbc_CAN.h; source line: 763; original CAN ID: 0x6A";

BO_ 108 AtmelResetSecurity: 8 Vector__XXX
CM_ BO_ 108 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 780; original CAN ID: 0x6C";

BO_ 109 ResetNetworkComm: 8 Vector__XXX
CM_ BO_ 109 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 744; original CAN ID: 0x6D";

BO_ 110 ResetAccessory1: 8 Vector__XXX
CM_ BO_ 110 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 745; original CAN ID: 0x6E";

BO_ 111 ResetAccessory2: 8 Vector__XXX
CM_ BO_ 111 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 746; original CAN ID: 0x6F";

BO_ 112 ResetWheelSpeed1: 8 Vector__XXX
CM_ BO_ 112 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 747; original CAN ID: 0x70";

BO_ 113 ResetWheelSpeed2: 8 Vector__XXX
CM_ BO_ 113 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 748; original CAN ID: 0x71";

BO_ 118 ResetTranslator: 8 Vector__XXX
CM_ BO_ 118 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 749; original CAN ID: 0x76";

BO_ 119 ResetTranslator2: 8 Vector__XXX
CM_ BO_ 119 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 750; original CAN ID: 0x77";

BO_ 120 ResetTeleOp: 8 Vector__XXX
CM_ BO_ 120 "Signal reference struct: ResetCauseMsg_t; source header: dbc_CAN.h; source line: 751; original CAN ID: 0x78";

BO_ 121 AtmelResetTeleop: 8 Vector__XXX
CM_ BO_ 121 "Signal reference struct: AtmelResetMsg_t; source header: dbc_CAN.h; source line: 781; original CAN ID: 0x79";

BO_ 128 ErrorFrontWheelSpeed: 8 Vector__XXX
CM_ BO_ 128 "Signal reference struct: ErrorWheelSpeed_t; source header: dbc_CAN.h; source line: 4131; original CAN ID: 0x80";

BO_ 129 ErrorRearWheelSpeed: 8 Vector__XXX
CM_ BO_ 129 "Signal reference struct: ErrorWheelSpeed_t; source header: dbc_CAN.h; source line: 4132; original CAN ID: 0x81";

BO_ 136 ErrorTeleOp: 8 Vector__XXX
CM_ BO_ 136 "Signal reference struct: ErrorTeleOp_t; source header: dbc_CAN.h; source line: 4156; original CAN ID: 0x88";

BO_ 272 AtmelLocalisaionError: 8 Vector__XXX
CM_ BO_ 272 "Signal reference struct: AtmelLocalisaionError_t; source header: dbc_CAN.h; source line: 4178; original CAN ID: 0x110";

BO_ 273 AtmelDriveError: 8 Vector__XXX
CM_ BO_ 273 "Signal reference struct: AtmelDriveError_t; source header: dbc_CAN.h; source line: 4208; original CAN ID: 0x111";

BO_ 276 AtmelManualError: 8 Vector__XXX
CM_ BO_ 276 "Signal reference struct: AtmelManualError_t; source header: dbc_CAN.h; source line: 4236; original CAN ID: 0x114";

BO_ 277 AtmelFusionError: 8 Vector__XXX
CM_ BO_ 277 "Signal reference struct: AtmelFusionError_t; source header: dbc_CAN.h; source line: 4258; original CAN ID: 0x115";

BO_ 280 AtmelTeleopError: 8 Vector__XXX
CM_ BO_ 280 "Signal reference struct: AtmelTeleopError_t; source header: dbc_CAN.h; source line: 4286; original CAN ID: 0x118";

BO_ 284 AtmelSecurityError: 8 Vector__XXX
CM_ BO_ 284 "Signal reference struct: AtmelSecurityError_t; source header: dbc_CAN.h; source line: 4298; original CAN ID: 0x11C";

BO_ 288 Obsolte_ObsLidarMsg: 8 Vector__XXX
CM_ BO_ 288 "Signal reference struct: ObstacleDetectionLiDARMsg_t; source header: dbc_CAN.h; source line: 1764; original CAN ID: 0x120";

BO_ 289 Obsolete_UltraSoundMsg: 8 Vector__XXX
CM_ BO_ 289 "Signal reference struct: UltraSoundMsg_t; source header: dbc_CAN.h; source line: 1800; original CAN ID: 0x121";

BO_ 290 ObstacleDangerZoneMsg: 8 Vector__XXX
CM_ BO_ 290 "Signal reference struct: ObstacleDangerZoneMsg_t; source header: dbc_CAN.h; source line: 2171; original CAN ID: 0x122";

BO_ 291 ObstacleTrackDistanceMsg: 8 Vector__XXX
CM_ BO_ 291 "Signal reference struct: ObstacleTrackDistanceMsg_t; source header: dbc_CAN.h; source line: 2203; original CAN ID: 0x123";

BO_ 292 ObstacleDangerZoneStopMsg: 8 Vector__XXX
CM_ BO_ 292 "Signal reference struct: ObstacleDangerZoneStopMsg_t; source header: dbc_CAN.h; source line: 2244; original CAN ID: 0x124";

BO_ 293 FrontPointDist: 8 Vector__XXX
CM_ BO_ 293 "Signal reference struct: PointDistanceMsg_t; source header: dbc_CAN.h; source line: 4642; original CAN ID: 0x125";

BO_ 294 RearPointDist: 8 Vector__XXX
CM_ BO_ 294 "Signal reference struct: PointDistanceMsg_t; source header: dbc_CAN.h; source line: 4643; original CAN ID: 0x126";

BO_ 304 TrafficLightMsg: 8 Vector__XXX
CM_ BO_ 304 "Signal reference struct: TrafficLightMsg_t; source header: dbc_CAN.h; source line: 664; original CAN ID: 0x130";

BO_ 336 EHBReqMsg: 8 Vector__XXX
CM_ BO_ 336 "Signal reference struct: EHBReqMsg_t; source header: dbc_CAN.h; source line: 1179; original CAN ID: 0x150";

BO_ 352 Obsolete_BrakeReqMsg: 8 Vector__XXX
CM_ BO_ 352 "Signal reference struct: BrakeReqMsg_t; source header: dbc_CAN.h; source line: 1855; original CAN ID: 0x160";

BO_ 353 Motor3ReqMsg: 8 Vector__XXX
CM_ BO_ 353 "Signal reference struct: Motor3ReqMsg_t; source header: additionalDbcCan.h; source line: 80; original CAN ID: 0x161";

BO_ 354 MotorReqMsg: 8 Vector__XXX
CM_ BO_ 354 "Signal reference struct: MotorReqMsg_t; source header: dbc_CAN.h; source line: 1386; original CAN ID: 0x162";

BO_ 355 frontSteeringReq: 8 Vector__XXX
CM_ BO_ 355 "Signal reference struct: SteeringReqMsg_t; source header: dbc_CAN.h; source line: 1421; original CAN ID: 0x163";

BO_ 356 rearSteeringReq: 8 Vector__XXX
CM_ BO_ 356 "Signal reference struct: SteeringReqMsg_t; source header: dbc_CAN.h; source line: 1422; original CAN ID: 0x164";

BO_ 357 Speed2TorqueReqMsg: 8 Vector__XXX
CM_ BO_ 357 "Signal reference struct: Speed2TorqueReqMsg_t; source header: dbc_CAN.h; source line: 1453; original CAN ID: 0x165";

BO_ 358 Speed2TorqueRespMsg: 8 Vector__XXX
CM_ BO_ 358 "Signal reference struct: Speed2TorqueRespMsg_t; source header: dbc_CAN.h; source line: 1654; original CAN ID: 0x166";

BO_ 384 ManualDriveMsg: 8 Vector__XXX
CM_ BO_ 384 "Signal reference struct: ManualDriveMsg_t; source header: dbc_CAN.h; source line: 1084; original CAN ID: 0x180";

BO_ 385 JoystickMsg: 8 Vector__XXX
CM_ BO_ 385 "Signal reference struct: JoystickMsg_t; source header: dbc_CAN.h; source line: 1129; original CAN ID: 0x181";

BO_ 387 TeleOpMsg: 8 Vector__XXX
CM_ BO_ 387 "Signal reference struct: JoystickMsg_t; source header: dbc_CAN.h; source line: 1130; original CAN ID: 0x183";

BO_ 389 LocManualMsg: 8 Vector__XXX
CM_ BO_ 389 "Signal reference struct: ManualDriveMsg_t; source header: dbc_CAN.h; source line: 1085; original CAN ID: 0x185";

BO_ 390 LocJoystickMsg: 8 Vector__XXX
CM_ BO_ 390 "Signal reference struct: JoystickMsg_t; source header: dbc_CAN.h; source line: 1131; original CAN ID: 0x186";

BO_ 391 TransDriveMsg: 8 Vector__XXX
CM_ BO_ 391 "Signal reference struct: ManualDriveMsg_t; source header: dbc_CAN.h; source line: 1086; original CAN ID: 0x187";

BO_ 392 TransJoystickMsg: 8 Vector__XXX
CM_ BO_ 392 "Signal reference struct: JoystickMsg_t; source header: dbc_CAN.h; source line: 1132; original CAN ID: 0x188";

BO_ 416 PlatoonDriveMsg: 8 Vector__XXX
CM_ BO_ 416 "Signal reference struct: InterVehicleCommsMsg_t; source header: dbc_CAN.h; source line: 4661; original CAN ID: 0x1A0";

BO_ 417 Vehicle1CommsMsg: 8 Vector__XXX
CM_ BO_ 417 "Signal reference struct: InterVehicleCommsMsg_t; source header: dbc_CAN.h; source line: 4662; original CAN ID: 0x1A1";

BO_ 418 Vehicle2CommsMsg: 8 Vector__XXX
CM_ BO_ 418 "Signal reference struct: InterVehicleCommsMsg_t; source header: dbc_CAN.h; source line: 4663; original CAN ID: 0x1A2";

BO_ 419 Vehicle3CommsMsg: 8 Vector__XXX
CM_ BO_ 419 "Signal reference struct: InterVehicleCommsMsg_t; source header: dbc_CAN.h; source line: 4664; original CAN ID: 0x1A3";

BO_ 512 TimestampMsg: 8 Vector__XXX
CM_ BO_ 512 "Signal reference struct: TimestampMsg_t; source header: dbc_CAN.h; source line: 182; original CAN ID: 0x200";

BO_ 513 DriveRequestsMsg: 8 Vector__XXX
CM_ BO_ 513 "Signal reference struct: DriveRequestsMsg_t; source header: dbc_CAN.h; source line: 1616; original CAN ID: 0x201";

BO_ 528 FusionLatitudeFrontMsg: 8 Vector__XXX
CM_ BO_ 528 "Signal reference struct: LatitudeMsg_t; source header: dbc_CAN.h; source line: 2554; original CAN ID: 0x210";

BO_ 529 FusionLongitudeFront: 8 Vector__XXX
CM_ BO_ 529 "Signal reference struct: LongitudeMsg_t; source header: dbc_CAN.h; source line: 2592; original CAN ID: 0x211";

BO_ 530 FusionInfoMsg: 8 Vector__XXX
CM_ BO_ 530 "Signal reference struct: FusionInfoMsg_t; source header: dbc_CAN.h; source line: 2627; original CAN ID: 0x212";

BO_ 531 FusionLatitudeRearMsg: 8 Vector__XXX
CM_ BO_ 531 "Signal reference struct: LatitudeMsg_t; source header: dbc_CAN.h; source line: 2555; original CAN ID: 0x213";

BO_ 532 FusionLongitudeRear: 8 Vector__XXX
CM_ BO_ 532 "Signal reference struct: LongitudeMsg_t; source header: dbc_CAN.h; source line: 2593; original CAN ID: 0x214";

BO_ 533 FusionBiasOutlierMsg: 8 Vector__XXX
CM_ BO_ 533 "Signal reference struct: FusionBiasOutlierMsg_t; source header: dbc_CAN.h; source line: 2837; original CAN ID: 0x215";

BO_ 534 VehicleInfoMsg: 8 Vector__XXX
CM_ BO_ 534 "Signal reference struct: VehicleInfoMsg_t; source header: dbc_CAN.h; source line: 2867; original CAN ID: 0x216";

BO_ 535 LidarLatitudeUndelayed: 8 Vector__XXX
CM_ BO_ 535 "Signal reference struct: LidarLatitudeUndelayed_t; source header: dbc_CAN.h; source line: 4492; original CAN ID: 0x217";

BO_ 536 LidarLongitudeUndelayed: 8 Vector__XXX
CM_ BO_ 536 "Signal reference struct: LidarLongitudeUndelayed_t; source header: dbc_CAN.h; source line: 4526; original CAN ID: 0x218";

BO_ 537 FusionFrontLatitude: 8 Vector__XXX
CM_ BO_ 537 "Signal reference struct: FusionFrontLatitude_t; source header: dbc_CAN.h; source line: 2896; original CAN ID: 0x219";

BO_ 538 FusionFrontLongitude: 8 Vector__XXX
CM_ BO_ 538 "Signal reference struct: FusionFrontLongitude_t; source header: additionalDbcCan.h; source line: 267; original CAN ID: 0x21A";

BO_ 539 FusionRearLatitude: 8 Vector__XXX
CM_ BO_ 539 "Signal reference struct: FusionRearLatitude_t; source header: dbc_CAN.h; source line: 2937; original CAN ID: 0x21B";

BO_ 540 FusionRearLongitude: 8 Vector__XXX
CM_ BO_ 540 "Signal reference struct: FusionRearLongitude_t; source header: dbc_CAN.h; source line: 2974; original CAN ID: 0x21C";

BO_ 541 FusionHeight: 8 Vector__XXX
CM_ BO_ 541 "Signal reference struct: FusionHeight_t; source header: dbc_CAN.h; source line: 3013; original CAN ID: 0x21D";

BO_ 544 Obsolete_latitudeFrontMsg: 8 Vector__XXX
CM_ BO_ 544 "Signal reference struct: GPSLatitudeMsg_t; source header: dbc_CAN.h; source line: 1867; original CAN ID: 0x220";

BO_ 545 Obsolete_longitudeFrontMsg: 8 Vector__XXX
CM_ BO_ 545 "Signal reference struct: LongitudeMsg_t; source header: dbc_CAN.h; source line: 2594; original CAN ID: 0x221";

BO_ 546 Obsolete_heightFrontMsg: 8 Vector__XXX
CM_ BO_ 546 "Signal reference struct: HeightMsg_t; source header: dbc_CAN.h; source line: 1900; original CAN ID: 0x222";

BO_ 547 Obsolete_combineHeightFrontMsg: 8 Vector__XXX
CM_ BO_ 547 "Signal reference struct: CombinedHeightMsg_t; source header: dbc_CAN.h; source line: 1934; original CAN ID: 0x223";

BO_ 549 frontGpsUbxPart1: 8 Vector__XXX
CM_ BO_ 549 "Signal reference struct: UBXPart1Msg_t; source header: dbc_CAN.h; source line: 26; original CAN ID: 0x225";

BO_ 550 frontGpsUbxPart2: 8 Vector__XXX
CM_ BO_ 550 "Signal reference struct: UBXPart2Msg_t; source header: dbc_CAN.h; source line: 61; original CAN ID: 0x226";

BO_ 551 frontGpsUbxPart3: 8 Vector__XXX
CM_ BO_ 551 "Signal reference struct: UBXPart3Msg_t; source header: dbc_CAN.h; source line: 104; original CAN ID: 0x227";

BO_ 560 Obsolete_latitudeBackMsg: 8 Vector__XXX
CM_ BO_ 560 "Signal reference struct: GPSLatitudeMsg_t; source header: dbc_CAN.h; source line: 1868; original CAN ID: 0x230";

BO_ 561 Obsolete_longitudeBackMsg: 8 Vector__XXX
CM_ BO_ 561 "Signal reference struct: LongitudeMsg_t; source header: dbc_CAN.h; source line: 2595; original CAN ID: 0x231";

BO_ 562 Obsolete_heightBackMsg: 8 Vector__XXX
CM_ BO_ 562 "Signal reference struct: HeightMsg_t; source header: dbc_CAN.h; source line: 1901; original CAN ID: 0x232";

BO_ 563 Obsolete_HeadingMsg: 8 Vector__XXX
CM_ BO_ 563 "Signal reference struct: HeadingMsg_t; source header: dbc_CAN.h; source line: 1961; original CAN ID: 0x233";

BO_ 564 Obsolete_combineHeightBackMsg: 8 Vector__XXX
CM_ BO_ 564 "Signal reference struct: CombinedHeightMsg_t; source header: dbc_CAN.h; source line: 1935; original CAN ID: 0x234";

BO_ 565 rearGpsUbxPart1: 8 Vector__XXX
CM_ BO_ 565 "Signal reference struct: UBXPart1Msg_t; source header: dbc_CAN.h; source line: 27; original CAN ID: 0x235";

BO_ 566 rearGpsUbxPart2: 8 Vector__XXX
CM_ BO_ 566 "Signal reference struct: UBXPart2Msg_t; source header: dbc_CAN.h; source line: 62; original CAN ID: 0x236";

BO_ 567 rearGpsUbxPart3: 8 Vector__XXX
CM_ BO_ 567 "Signal reference struct: UBXPart3Msg_t; source header: dbc_CAN.h; source line: 105; original CAN ID: 0x237";

BO_ 576 LidarSpeed: 8 Vector__XXX
CM_ BO_ 576 "Signal reference struct: LidarSpeed_t; source header: dbc_CAN.h; source line: 2337; original CAN ID: 0x240";

BO_ 577 LidarLatitude: 8 Vector__XXX
CM_ BO_ 577 "Signal reference struct: ObsLatitudeMsg_t; source header: dbc_CAN.h; source line: 2397; original CAN ID: 0x241";

BO_ 578 LidarLongitude: 8 Vector__XXX
CM_ BO_ 578 "Signal reference struct: ObsLongitudeMsg_t; source header: dbc_CAN.h; source line: 2438; original CAN ID: 0x242";

BO_ 579 LidarHeading: 8 Vector__XXX
CM_ BO_ 579 "Signal reference struct: ObsHeadingMsg_t; source header: dbc_CAN.h; source line: 2474; original CAN ID: 0x243";

BO_ 581 CameraLatitude: 8 Vector__XXX
CM_ BO_ 581 "Signal reference struct: ObsLatitudeMsg_t; source header: dbc_CAN.h; source line: 2398; original CAN ID: 0x245";

BO_ 582 CameraLongitude: 8 Vector__XXX
CM_ BO_ 582 "Signal reference struct: ObsLongitudeMsg_t; source header: dbc_CAN.h; source line: 2439; original CAN ID: 0x246";

BO_ 583 CameraHeading: 8 Vector__XXX
CM_ BO_ 583 "Signal reference struct: ObsHeadingMsg_t; source header: dbc_CAN.h; source line: 2475; original CAN ID: 0x247";

BO_ 592 Obsolete_UWBDistanceMsg: 8 Vector__XXX
CM_ BO_ 592 "Signal reference struct: UWBDistanceMsg_t; source header: dbc_CAN.h; source line: 2013; original CAN ID: 0x250";

BO_ 593 Obsolete_UWBLatitudeMsg: 8 Vector__XXX
CM_ BO_ 593 "Signal reference struct: UWBLatitudeMsg_t; source header: dbc_CAN.h; source line: 2029; original CAN ID: 0x251";

BO_ 594 Obsolete_UWBLongitudeMsg: 8 Vector__XXX
CM_ BO_ 594 "Signal reference struct: UWBLongitudeMsg_t; source header: dbc_CAN.h; source line: 2055; original CAN ID: 0x252";

BO_ 608 Obsolete_CompassMsg: 8 Vector__XXX
CM_ BO_ 608 "Signal reference struct: CompassMsg_t; source header: dbc_CAN.h; source line: 1986; original CAN ID: 0x260";

BO_ 624 LidarOffset: 8 Vector__XXX
CM_ BO_ 624 "Signal reference struct: ObsTrackOffsetMsg_t; source header: dbc_CAN.h; source line: 2520; original CAN ID: 0x270";

BO_ 625 CameraOffset: 8 Vector__XXX
CM_ BO_ 625 "Signal reference struct: ObsTrackOffsetMsg_t; source header: dbc_CAN.h; source line: 2521; original CAN ID: 0x271";

BO_ 640 frontSteeringStatus: 8 Vector__XXX
CM_ BO_ 640 "Signal reference struct: SteeringStatusMsg_t; source header: dbc_CAN.h; source line: 888; original CAN ID: 0x280";

BO_ 641 rearSteeringStatus: 8 Vector__XXX
CM_ BO_ 641 "Signal reference struct: SteeringStatusMsg_t; source header: dbc_CAN.h; source line: 889; original CAN ID: 0x281";

BO_ 656 Motor1Status: 8 Vector__XXX
CM_ BO_ 656 "Signal reference struct: MotorStatus_t; source header: dbc_CAN.h; source line: 3584; original CAN ID: 0x290";

BO_ 657 Motor2Status: 8 Vector__XXX
CM_ BO_ 657 "Signal reference struct: MotorStatus_t; source header: dbc_CAN.h; source line: 3585; original CAN ID: 0x291";

BO_ 661 Motor3Status1: 8 Vector__XXX
CM_ BO_ 661 "Signal reference struct: Motor3Status1_t; source header: additionalDbcCan.h; source line: 13; original CAN ID: 0x295";

BO_ 662 Motor3Status2: 8 Vector__XXX
CM_ BO_ 662 "Signal reference struct: Motor3Status2_t; source header: dbc_CAN.h; source line: 3627; original CAN ID: 0x296";

BO_ 688 EPBReqMsg: 8 Vector__XXX
CM_ BO_ 688 "Signal reference struct: EPBReqMsg_t; source header: dbc_CAN.h; source line: 1486; original CAN ID: 0x2B0";

BO_ 693 EPB1Status: 7 Vector__XXX
CM_ BO_ 693 "Signal reference struct: EPBStatusMsg_t; source header: dbc_CAN.h; source line: 285; original CAN ID: 0x2B5";

BO_ 694 EPB2Status: 7 Vector__XXX
CM_ BO_ 694 "Signal reference struct: EPBStatusMsg_t; source header: dbc_CAN.h; source line: 286; original CAN ID: 0x2B6";

BO_ 704 FusionAcceMsg: 8 Vector__XXX
CM_ BO_ 704 "Signal reference struct: FusionAcceMsg_t; source header: dbc_CAN.h; source line: 2665; original CAN ID: 0x2C0";

BO_ 709 DeviationReqMsg: 8 Vector__XXX
CM_ BO_ 709 "Signal reference struct: DeviationReqMsg_t; source header: additionalDbcCan.h; source line: 223; original CAN ID: 0x2C5";

BO_ 768 DynamicTrackValidationMsg: 8 Vector__XXX
CM_ BO_ 768 "Signal reference struct: DynamicTrackValidationMsg_t; source header: additionalDbcCan.h; source line: 163; original CAN ID: 0x300";

BO_ 784 ParameterConfMsg: 8 Vector__XXX
CM_ BO_ 784 "Signal reference struct: ParameterConfMsg_t; source header: dbc_CAN.h; source line: 384; original CAN ID: 0x310";

BO_ 785 ConfigResp: 8 Vector__XXX
CM_ BO_ 785 "Signal reference struct: ConfigRespMsg_t; source header: dbc_CAN.h; source line: 359; original CAN ID: 0x311";

BO_ 786 VersionReqMsg: 8 Vector__XXX
CM_ BO_ 786 "Signal reference struct: VersionReqMsg_t; source header: dbc_CAN.h; source line: 413; original CAN ID: 0x312";

BO_ 787 VersionRespMsg: 8 Vector__XXX
CM_ BO_ 787 "Signal reference struct: VersionRespMsg_t; source header: dbc_CAN.h; source line: 3449; original CAN ID: 0x313";

BO_ 788 BootloaderVersionRespMsg: 8 Vector__XXX
CM_ BO_ 788 "Signal reference struct: VersionRespMsg_t; source header: dbc_CAN.h; source line: 3450; original CAN ID: 0x314";

BO_ 789 OcanDBCVersionMsg: 8 Vector__XXX
CM_ BO_ 789 "Signal reference struct: VersionRespMsg_t; source header: dbc_CAN.h; source line: 3451; original CAN ID: 0x315";

BO_ 790 PcanDBCVersionMsg: 8 Vector__XXX
CM_ BO_ 790 "Signal reference struct: VersionRespMsg_t; source header: dbc_CAN.h; source line: 3452; original CAN ID: 0x316";

BO_ 791 ParameterConfSignMsg: 8 Vector__XXX
CM_ BO_ 791 "Signal reference struct: ParameterConfSignMsg_t; source header: dbc_CAN.h; source line: 425; original CAN ID: 0x317";

BO_ 792 ConfigSignResp: 8 Vector__XXX
CM_ BO_ 792 "Signal reference struct: ConfigRespMsg_t; source header: dbc_CAN.h; source line: 360; original CAN ID: 0x318";

BO_ 800 SystemReqMsg: 8 Vector__XXX
CM_ BO_ 800 "Signal reference struct: SystemReqMsg_t; source header: dbc_CAN.h; source line: 452; original CAN ID: 0x320";

BO_ 801 Obsolete_DriveInfoMsg: 8 Vector__XXX
CM_ BO_ 801 "Signal reference struct: DriveInfoMsg_t; source header: dbc_CAN.h; source line: 2081; original CAN ID: 0x321";

BO_ 802 StartupStatusMsg: 5 Vector__XXX
CM_ BO_ 802 "Signal reference struct: StartupStatusMsg_t; source header: dbc_CAN.h; source line: 814; original CAN ID: 0x322";

BO_ 803 LoadingReqMsg: 8 Vector__XXX
CM_ BO_ 803 "Signal reference struct: LoadingReqMsg_t; source header: dbc_CAN.h; source line: 1162; original CAN ID: 0x323";

BO_ 804 SecuritySpeedMsg: 8 Vector__XXX
CM_ BO_ 804 "Signal reference struct: SecuritySpeedMsg_t; source header: dbc_CAN.h; source line: 4407; original CAN ID: 0x324";

BO_ 805 DriveInfoLongWpMsg: 8 Vector__XXX
CM_ BO_ 805 "Signal reference struct: DriveInfoLongWpMsg_t; source header: dbc_CAN.h; source line: 1498; original CAN ID: 0x325";

BO_ 806 StopReqMsg: 8 Vector__XXX
CM_ BO_ 806 "Signal reference struct: StopReqMsg_t; source header: additionalDbcCan.h; source line: 193; original CAN ID: 0x326";

BO_ 807 ObsTiedMarginMsg: 8 Vector__XXX
CM_ BO_ 807 "Signal reference struct: ObsTiedMarginMsg_t; source header: dbc_CAN.h; source line: 1676; original CAN ID: 0x327";

BO_ 808 DriveInfo500kWpMsg: 8 Vector__XXX
CM_ BO_ 808 "Signal reference struct: DriveInfo500kWpMsg_t; source header: dbc_CAN.h; source line: 1540; original CAN ID: 0x328";

BO_ 816 EHBStatusMsg: 8 Vector__XXX
CM_ BO_ 816 "Signal reference struct: EHBStatusMsg_t; source header: dbc_CAN.h; source line: 960; original CAN ID: 0x330";

BO_ 817 EHBPowerMsg: 8 Vector__XXX
CM_ BO_ 817 "Signal reference struct: EHBPowerMsg_t; source header: dbc_CAN.h; source line: 984; original CAN ID: 0x331";

BO_ 818 EHBT060PowerMsg: 8 Vector__XXX
CM_ BO_ 818 "Signal reference struct: EHBT060PowerMsg_t; source header: dbc_CAN.h; source line: 1034; original CAN ID: 0x332";

BO_ 832 EPBReleaseMsg: 8 Vector__XXX
CM_ BO_ 832 "Signal reference struct: EPBReleaseMsg_t; source header: dbc_CAN.h; source line: 472; original CAN ID: 0x340";

BO_ 1024 BatteryStatusMsg: 8 Vector__XXX
CM_ BO_ 1024 "Signal reference struct: BatteryStatusMsg_t; source header: dbc_CAN.h; source line: 4310; original CAN ID: 0x400";

BO_ 1040 LiveUpdateReqMsg: 8 Vector__XXX
CM_ BO_ 1040 "Signal reference struct: LiveUpdateReqMsg_t; source header: dbc_CAN.h; source line: 618; original CAN ID: 0x410";

BO_ 1041 LiveUpdateACKMsg: 8 Vector__XXX
CM_ BO_ 1041 "Signal reference struct: LiveUpdateACKMsg_t; source header: dbc_CAN.h; source line: 3480; original CAN ID: 0x411";

BO_ 1056 LiveUpdateData: 8 Vector__XXX
CM_ BO_ 1056 "Signal reference struct: LiveUpdateMsg_t; source header: dbc_CAN.h; source line: 3571; original CAN ID: 0x420";

BO_ 1057 LiveUpdateRespMsg: 8 Vector__XXX
CM_ BO_ 1057 "Signal reference struct: LiveUpdateMsg_t; source header: dbc_CAN.h; source line: 3572; original CAN ID: 0x421";

BO_ 1058 AtmelUpdateReqMsg: 8 Vector__XXX
CM_ BO_ 1058 "Signal reference struct: AtmelUpdateReqMsg_t; source header: dbc_CAN.h; source line: 692; original CAN ID: 0x422";

BO_ 1059 AtmelUpdateRespMsg: 8 Vector__XXX
CM_ BO_ 1059 "Signal reference struct: AtmelUpdateRespMsg_t; source header: dbc_CAN.h; source line: 4602; original CAN ID: 0x423";

BO_ 1296 frontReqIndicatorBrake: 8 Vector__XXX
CM_ BO_ 1296 "Signal reference struct: IndicatorBrakeStatusAndReqMsg_t; source header: dbc_CAN.h; source line: 342; original CAN ID: 0x510";

BO_ 1297 rearReqIndicatorBrake: 8 Vector__XXX
CM_ BO_ 1297 "Signal reference struct: IndicatorBrakeStatusAndReqMsg_t; source header: dbc_CAN.h; source line: 343; original CAN ID: 0x511";

BO_ 1312 frontStatusIndicatorBrake: 8 Vector__XXX
CM_ BO_ 1312 "Signal reference struct: IndicatorBrakeStatusAndReqMsg_t; source header: dbc_CAN.h; source line: 344; original CAN ID: 0x520";

BO_ 1313 rearStatusIndicatorBrake: 8 Vector__XXX
CM_ BO_ 1313 "Signal reference struct: IndicatorBrakeStatusAndReqMsg_t; source header: dbc_CAN.h; source line: 345; original CAN ID: 0x521";

BO_ 1328 FrontRightIndicatorLightReqMsg: 8 Vector__XXX
CM_ BO_ 1328 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 793; original CAN ID: 0x530";

BO_ 1329 FrontRightIndicatorLightStatusMsg: 8 Vector__XXX
CM_ BO_ 1329 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 794; original CAN ID: 0x531";

BO_ 1344 FrontLeftIndicatorLightReqMsg: 8 Vector__XXX
CM_ BO_ 1344 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 795; original CAN ID: 0x540";

BO_ 1345 FrontLeftIndicatorLightStatusMsg: 8 Vector__XXX
CM_ BO_ 1345 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 796; original CAN ID: 0x541";

BO_ 1360 RearBrakeLightReqMsg: 8 Vector__XXX
CM_ BO_ 1360 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 797; original CAN ID: 0x550";

BO_ 1361 RearBrakeLightStatusMsg: 8 Vector__XXX
CM_ BO_ 1361 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 798; original CAN ID: 0x551";

BO_ 1376 RearRightIndicatorLightReqMsg: 8 Vector__XXX
CM_ BO_ 1376 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 799; original CAN ID: 0x560";

BO_ 1377 RearRightIndicatorLightStatusMsg: 8 Vector__XXX
CM_ BO_ 1377 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 800; original CAN ID: 0x561";

BO_ 1392 RearLeftIndicatorLightReqMsg: 8 Vector__XXX
CM_ BO_ 1392 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 801; original CAN ID: 0x570";

BO_ 1393 RearLeftIndicatorLightStatusMsg: 8 Vector__XXX
CM_ BO_ 1393 "Signal reference struct: IndicatorBrakeLightMsg_t; source header: dbc_CAN.h; source line: 802; original CAN ID: 0x571";

BO_ 1408 Motor3Status3: 8 Vector__XXX
CM_ BO_ 1408 "Signal reference struct: Motor3Status3_t; source header: dbc_CAN.h; source line: 3658; original CAN ID: 0x580";

BO_ 1409 Motor3Status4: 8 Vector__XXX
CM_ BO_ 1409 "Signal reference struct: Motor3Status4_t; source header: dbc_CAN.h; source line: 3682; original CAN ID: 0x581";

BO_ 1410 Motor3Status5: 8 Vector__XXX
CM_ BO_ 1410 "Signal reference struct: Motor3Status5_t; source header: dbc_CAN.h; source line: 3699; original CAN ID: 0x582";

BO_ 1411 Motor3Status6: 8 Vector__XXX
CM_ BO_ 1411 "Signal reference struct: Motor3Status6_t; source header: dbc_CAN.h; source line: 3731; original CAN ID: 0x583";

BO_ 1412 BMSStatusStdMsg: 8 Vector__XXX
CM_ BO_ 1412 "Signal reference struct: BMSStatusStdMsg_t; source header: dbc_CAN.h; source line: 847; original CAN ID: 0x584";

BO_ 1424 RemoteSignalMsg: 8 Vector__XXX
CM_ BO_ 1424 "Signal reference struct: RemoteSignalMsg_t; source header: dbc_CAN.h; source line: 3847; original CAN ID: 0x590";

BO_ 1440 ExtObsLocMsg: 8 Vector__XXX
CM_ BO_ 1440 "Signal reference struct: ExtObsLocMsg_t; source header: dbc_CAN.h; source line: 1708; original CAN ID: 0x5A0";

BO_ 1441 ExtObsSpeedMsg: 8 Vector__XXX
CM_ BO_ 1441 "Signal reference struct: ExtObsSpeedMsg_t; source header: dbc_CAN.h; source line: 1730; original CAN ID: 0x5A1";

BO_ 1536 ErrorReportMsg: 6 Vector__XXX
CM_ BO_ 1536 "Signal reference struct: ErrorReportMsg_t; source header: dbc_CAN.h; source line: 833; original CAN ID: 0x600";

BO_ 1546 SecurityWarningMsg: 8 Vector__XXX
CM_ BO_ 1546 "Signal reference struct: SecurityWarningMsg_t; source header: dbc_CAN.h; source line: 4419; original CAN ID: 0x60A";

BO_ 1552 FileTransferMsg: 8 Vector__XXX
CM_ BO_ 1552 "Signal reference struct: FileTransferMsg_t; source header: dbc_CAN.h; source line: 3493; original CAN ID: 0x610";

BO_ 1553 FileAckMsg: 8 Vector__XXX
CM_ BO_ 1553 "Signal reference struct: TransferAckMsg_t; source header: dbc_CAN.h; source line: 3509; original CAN ID: 0x611";

BO_ 1554 DataTransferMsg: 8 Vector__XXX
CM_ BO_ 1554 "Signal reference struct: DataTransferMsg_t; source header: dbc_CAN.h; source line: 3526; original CAN ID: 0x612";

BO_ 1555 DataAckMsg: 8 Vector__XXX
CM_ BO_ 1555 "Signal reference struct: TransferAckMsg_t; source header: dbc_CAN.h; source line: 3510; original CAN ID: 0x613";

BO_ 1569 IMURot: 8 Vector__XXX
CM_ BO_ 1569 "Signal reference struct: IMURot_t; source header: dbc_CAN.h; source line: 3249; original CAN ID: 0x621";

BO_ 1570 IMUAcc: 8 Vector__XXX
CM_ BO_ 1570 "Signal reference struct: IMUAcc_t; source header: dbc_CAN.h; source line: 3293; original CAN ID: 0x622";

BO_ 1571 IMUGyr: 8 Vector__XXX
CM_ BO_ 1571 "Signal reference struct: IMUGyr_t; source header: dbc_CAN.h; source line: 3331; original CAN ID: 0x623";

BO_ 1572 IMUStatus: 8 Vector__XXX
CM_ BO_ 1572 "Signal reference struct: IMUStatus_t; source header: dbc_CAN.h; source line: 3374; original CAN ID: 0x624";

BO_ 1584 ConnectWp: 8 Vector__XXX
CM_ BO_ 1584 "Signal reference struct: ConnectWp_t; source header: dbc_CAN.h; source line: 707; original CAN ID: 0x630";

BO_ 1616 TrackCtrlManageMsg: 8 Vector__XXX
CM_ BO_ 1616 "Signal reference struct: TrackCtrlMsg_t; source header: dbc_CAN.h; source line: 485; original CAN ID: 0x650";

BO_ 1617 TrackAckManageMsg: 8 Vector__XXX
CM_ BO_ 1617 "Signal reference struct: TrackAckMsg_t; source header: dbc_CAN.h; source line: 502; original CAN ID: 0x651";

BO_ 1618 TrackDataManageMsg: 8 Vector__XXX
CM_ BO_ 1618 "Signal reference struct: TrackDataMsg_t; source header: dbc_CAN.h; source line: 517; original CAN ID: 0x652";

BO_ 1632 TrackCtrlDriveMsg: 8 Vector__XXX
CM_ BO_ 1632 "Signal reference struct: TrackCtrlMsg_t; source header: dbc_CAN.h; source line: 486; original CAN ID: 0x660";

BO_ 1633 TrackAckDriveMsg: 8 Vector__XXX
CM_ BO_ 1633 "Signal reference struct: TrackAckMsg_t; source header: dbc_CAN.h; source line: 503; original CAN ID: 0x661";

BO_ 1634 TrackDataDriveMsg: 8 Vector__XXX
CM_ BO_ 1634 "Signal reference struct: TrackDataMsg_t; source header: dbc_CAN.h; source line: 518; original CAN ID: 0x662";

BO_ 1635 TrackMD5ReqMsg: 8 Vector__XXX
CM_ BO_ 1635 "Signal reference struct: TrackMD5ReqMsg_t; source header: dbc_CAN.h; source line: 1227; original CAN ID: 0x663";

BO_ 1636 platStartTxMsg: 8 Vector__XXX
CM_ BO_ 1636 "Signal reference struct: PlatStartMsg_t; source header: dbc_CAN.h; source line: 4694; original CAN ID: 0x664";

BO_ 1648 TrackCtrlObsMsg: 8 Vector__XXX
CM_ BO_ 1648 "Signal reference struct: TrackCtrlMsg_t; source header: dbc_CAN.h; source line: 487; original CAN ID: 0x670";

BO_ 1649 TrackAckObsMsg: 8 Vector__XXX
CM_ BO_ 1649 "Signal reference struct: TrackAckMsg_t; source header: dbc_CAN.h; source line: 504; original CAN ID: 0x671";

BO_ 1650 TrackDataObsMsg: 8 Vector__XXX
CM_ BO_ 1650 "Signal reference struct: TrackDataMsg_t; source header: dbc_CAN.h; source line: 519; original CAN ID: 0x672";

BO_ 1651 TrackMD5RespMsg: 8 Vector__XXX
CM_ BO_ 1651 "Signal reference struct: TrackMD5RespMsg_t; source header: dbc_CAN.h; source line: 3468; original CAN ID: 0x673";

BO_ 1652 platStartRxMsg: 8 Vector__XXX
CM_ BO_ 1652 "Signal reference struct: PlatStartMsg_t; source header: dbc_CAN.h; source line: 4695; original CAN ID: 0x674";

BO_ 1664 SteerCalibrationMsg: 8 Vector__XXX
CM_ BO_ 1664 "Signal reference struct: SteerCalibrationMsg_t; source header: dbc_CAN.h; source line: 533; original CAN ID: 0x680";

BO_ 1665 SteerConfigMsg: 8 Vector__XXX
CM_ BO_ 1665 "Signal reference struct: SteerConfigMsg_t; source header: dbc_CAN.h; source line: 565; original CAN ID: 0x681";

BO_ 1666 SteerConfigReqMsg: 8 Vector__XXX
CM_ BO_ 1666 "Signal reference struct: SteerConfigReqMsg_t; source header: dbc_CAN.h; source line: 577; original CAN ID: 0x682";

BO_ 1667 SteeringRespMsg: 8 Vector__XXX
CM_ BO_ 1667 "Signal reference struct: SteeringRespMsg_t; source header: dbc_CAN.h; source line: 928; original CAN ID: 0x683";

BO_ 1680 SteerMsg: 8 Vector__XXX
CM_ BO_ 1680 "Signal reference struct: SteerMsg_t; source header: dbc_CAN.h; source line: 590; original CAN ID: 0x690";

BO_ 1792 OdometerMsg: 8 Vector__XXX
CM_ BO_ 1792 "Signal reference struct: OdometerMsg_t; source header: dbc_CAN.h; source line: 1631; original CAN ID: 0x700";

BO_ 1793 OdometryParameters: 8 Vector__XXX
CM_ BO_ 1793 "Signal reference struct: OdometryParameters_t; source header: dbc_CAN.h; source line: 4554; original CAN ID: 0x701";

BO_ 1799 ObstaclePcWarning: 8 Vector__XXX
CM_ BO_ 1799 "Signal reference struct: ObstaclePcWarning_t; source header: dbc_CAN.h; source line: 3395; original CAN ID: 0x707";

BO_ 1808 Obsolete_LogIndMsg: 8 Vector__XXX
CM_ BO_ 1808 "Signal reference struct: LogIndMsg_t; source header: dbc_CAN.h; source line: 2127; original CAN ID: 0x710";

BO_ 1810 PlatDebugMsg: 8 Vector__XXX
CM_ BO_ 1810 "Signal reference struct: PlatDebugMsg_t; source header: dbc_CAN.h; source line: 1356; original CAN ID: 0x712";

BO_ 1811 StopDebugMsg: 8 Vector__XXX
CM_ BO_ 1811 "Signal reference struct: StopDebugMsg_t; source header: dbc_CAN.h; source line: 1368; original CAN ID: 0x713";

BO_ 1824 DebugMsg: 8 Vector__XXX
CM_ BO_ 1824 "Signal reference struct: DebugMsg_t; source header: dbc_CAN.h; source line: 1569; original CAN ID: 0x720";

BO_ 1828 FusionFlagsMsg: 8 Vector__XXX
CM_ BO_ 1828 "Signal reference struct: FusionFlagsMsg_t; source header: dbc_CAN.h; source line: 3047; original CAN ID: 0x724";

BO_ 1829 ErrorFusionDebugMsg: 8 Vector__XXX
CM_ BO_ 1829 "Signal reference struct: ErrorFusionDebugMsg_t; source header: dbc_CAN.h; source line: 3111; original CAN ID: 0x725";

BO_ 1831 IMUMag: 8 Vector__XXX
CM_ BO_ 1831 "Signal reference struct: IMUMag_t; source header: dbc_CAN.h; source line: 3212; original CAN ID: 0x727";

BO_ 1856 WheelSpeedEvents: 8 Vector__XXX
CM_ BO_ 1856 "Signal reference struct: WheelSpeedEvents_t; source header: dbc_CAN.h; source line: 241; original CAN ID: 0x740";

BO_ 1873 PlatoonSimMsg: 8 Vector__XXX
CM_ BO_ 1873 "Signal reference struct: PlatoonSimMsg_t; source header: dbc_CAN.h; source line: 4619; original CAN ID: 0x751";

BO_ 1893 fusionExceptionMsg: 8 Vector__XXX
CM_ BO_ 1893 "Signal reference struct: ExceptionMsg_t; source header: dbc_CAN.h; source line: 3554; original CAN ID: 0x765";

BO_ 1984 frontWheelExceptionMsg: 8 Vector__XXX
CM_ BO_ 1984 "Signal reference struct: ExceptionMsg_t; source header: dbc_CAN.h; source line: 3555; original CAN ID: 0x7C0";

BO_ 1985 rearWheelExceptionMsg: 8 Vector__XXX
CM_ BO_ 1985 "Signal reference struct: ExceptionMsg_t; source header: dbc_CAN.h; source line: 3556; original CAN ID: 0x7C1";

BO_ 2032 AnyExceptionMsg: 8 Vector__XXX
CM_ BO_ 2032 "Signal reference struct: AnyExceptionMsg_t; source header: dbc_CAN.h; source line: 3540; original CAN ID: 0x7F0";

BO_ 2034 EmulatorLatitudeMsg: 8 Vector__XXX
CM_ BO_ 2034 "Signal reference struct: LatitudeMsg_t; source header: dbc_CAN.h; source line: 2556; original CAN ID: 0x7F2";

BO_ 2035 EmulatorLongitude: 8 Vector__XXX
CM_ BO_ 2035 "Signal reference struct: LongitudeMsg_t; source header: dbc_CAN.h; source line: 2596; original CAN ID: 0x7F3";

BO_ 2036 EmulatorHeadingMsg: 8 Vector__XXX
CM_ BO_ 2036 "Signal reference struct: EmulatorHeadingMsg_t; source header: dbc_CAN.h; source line: 1690; original CAN ID: 0x7F4";
