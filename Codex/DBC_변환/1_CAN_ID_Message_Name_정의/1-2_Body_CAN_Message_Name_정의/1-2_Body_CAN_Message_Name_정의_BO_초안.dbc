VERSION "1-2_Body_CAN_Message_Name_BO_Draft"

NS_:
    CM_

BS_: 250000

BU_: Vector__XXX

BO_ 2164588560 AVASReqMsg: 8 Vector__XXX
CM_ BO_ 2164588560 "Signal reference struct: AVASReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 199; original CAN ID: 0x1050010";

BO_ 2164588575 AVASStatusMsg: 8 Vector__XXX
CM_ BO_ 2164588575 "Signal reference struct: AVASStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 1135; original CAN ID: 0x105001F";

BO_ 2208538887 BmsLotteTotalChangeValue: 8 Vector__XXX
CM_ BO_ 2208538887 "Signal reference struct: BmsLotteTotalChangeValue_t; source header: dbc_CAN_peripheral.h; source line: 1607; original CAN ID: 0x3A3A107";

BO_ 2222981531 CollisionEventInfo: 8 Vector__XXX
CM_ BO_ 2222981531 "Signal reference struct: CollisionEventInfo_t; source header: Security_CAN.h; source line: 8; original CAN ID: 0x480019B";

BO_ 2223243675 CollisionEventConfig1: 8 Vector__XXX
CM_ BO_ 2223243675 "Signal reference struct: CollisionEventConfig1_t; source header: Security_CAN.h; source line: 25; original CAN ID: 0x484019B";

BO_ 2355557621 BMSReqMsg: 8 Vector__XXX
CM_ BO_ 2355557621 "Signal reference struct: BMSReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 11; original CAN ID: 0xC66F4F5";

BO_ 2364539631 BmsLotteVehiclecontroller: 8 Vector__XXX
CM_ BO_ 2364539631 "Signal reference struct: BmsLotteVehiclecontroller_t; source header: dbc_CAN_peripheral.h; source line: 1640; original CAN ID: 0xCF002EF";

BO_ 2364866852 BmsLotteStatus: 8 Vector__XXX
CM_ BO_ 2364866852 "Signal reference struct: BmsLotteStatus_t; source header: dbc_CAN_peripheral.h; source line: 1216; original CAN ID: 0xCF50124";

BO_ 2418016256 voiceReq: 8 Vector__XXX
CM_ BO_ 2418016256 "Signal reference struct: VoiceMsg_t; source header: dbc_CAN_peripheral.h; source line: 25; original CAN ID: 0x10200000";

BO_ 2418016271 voiceResp: 8 Vector__XXX
CM_ BO_ 2418016271 "Signal reference struct: VoiceMsg_t; source header: dbc_CAN_peripheral.h; source line: 26; original CAN ID: 0x1020000F";

BO_ 2419065088 FrontMainLightReqMsg: 8 Vector__XXX
CM_ BO_ 2419065088 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 39; original CAN ID: 0x10300100";

BO_ 2419065103 FrontMainLightStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065103 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 40; original CAN ID: 0x1030010F";

BO_ 2419065104 FrontDipLightReqMsg: 8 Vector__XXX
CM_ BO_ 2419065104 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 41; original CAN ID: 0x10300110";

BO_ 2419065119 FrontDipLightStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065119 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 42; original CAN ID: 0x1030011F";

BO_ 2419065120 FrontDayLightReqMsg: 8 Vector__XXX
CM_ BO_ 2419065120 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 43; original CAN ID: 0x10300120";

BO_ 2419065135 FrontDayLightStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065135 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 44; original CAN ID: 0x1030012F";

BO_ 2419065136 FrontPosOutlineMarkerReqMsg: 8 Vector__XXX
CM_ BO_ 2419065136 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 45; original CAN ID: 0x10300130";

BO_ 2419065151 FrontPosOutlineMarkerStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065151 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 46; original CAN ID: 0x1030013F";

BO_ 2419065344 RearReverseLightReqMsg: 8 Vector__XXX
CM_ BO_ 2419065344 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 47; original CAN ID: 0x10300200";

BO_ 2419065359 RearReverseLightStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065359 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 48; original CAN ID: 0x1030020F";

BO_ 2419065360 RearTailOutlineMarkerReqMsg: 8 Vector__XXX
CM_ BO_ 2419065360 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 49; original CAN ID: 0x10300210";

BO_ 2419065375 RearTailOutlineMarkerStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065375 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 50; original CAN ID: 0x1030021F";

BO_ 2419065376 RearRegLightReqMsg: 8 Vector__XXX
CM_ BO_ 2419065376 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 51; original CAN ID: 0x10300220";

BO_ 2419065391 RearRegLightStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065391 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 52; original CAN ID: 0x1030022F";

BO_ 2419065600 HornReqMsg: 8 Vector__XXX
CM_ BO_ 2419065600 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 53; original CAN ID: 0x10300300";

BO_ 2419065615 HornStatusMsg: 8 Vector__XXX
CM_ BO_ 2419065615 "Signal reference struct: LightMsg_t; source header: dbc_CAN_peripheral.h; source line: 54; original CAN ID: 0x1030030F";

BO_ 2420113408 FrontLightReq: 8 Vector__XXX
CM_ BO_ 2420113408 "Signal reference struct: FrontLightMsg_t; source header: dbc_CAN_peripheral.h; source line: 66; original CAN ID: 0x10400000";

BO_ 2420113415 FrontLightStatus: 8 Vector__XXX
CM_ BO_ 2420113415 "Signal reference struct: FrontLightMsg_t; source header: dbc_CAN_peripheral.h; source line: 67; original CAN ID: 0x10400007";

BO_ 2420113416 RearLightReq: 8 Vector__XXX
CM_ BO_ 2420113416 "Signal reference struct: RearLightMsg_t; source header: dbc_CAN_peripheral.h; source line: 83; original CAN ID: 0x10400008";

BO_ 2420113423 RearLightStatus: 8 Vector__XXX
CM_ BO_ 2420113423 "Signal reference struct: RearLightMsg_t; source header: dbc_CAN_peripheral.h; source line: 84; original CAN ID: 0x1040000F";

BO_ 2420113424 OvalFrontLeftStatus: 8 Vector__XXX
CM_ BO_ 2420113424 "Signal reference struct: OvalLightStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 102; original CAN ID: 0x10400010";

BO_ 2420113439 OvalFrontLeftReq: 8 Vector__XXX
CM_ BO_ 2420113439 "Signal reference struct: OvalLightReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 124; original CAN ID: 0x1040001F";

BO_ 2420113440 OvalFrontRightStatus: 8 Vector__XXX
CM_ BO_ 2420113440 "Signal reference struct: OvalLightStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 103; original CAN ID: 0x10400020";

BO_ 2420113455 OvalFrontRightReq: 8 Vector__XXX
CM_ BO_ 2420113455 "Signal reference struct: OvalLightReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 125; original CAN ID: 0x1040002F";

BO_ 2420113456 OvalRearLeftStatus: 8 Vector__XXX
CM_ BO_ 2420113456 "Signal reference struct: OvalLightStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 104; original CAN ID: 0x10400030";

BO_ 2420113471 OvalRearLeftReq: 8 Vector__XXX
CM_ BO_ 2420113471 "Signal reference struct: OvalLightReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 126; original CAN ID: 0x1040003F";

BO_ 2420113472 OvalRearRightStatus: 8 Vector__XXX
CM_ BO_ 2420113472 "Signal reference struct: OvalLightStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 105; original CAN ID: 0x10400040";

BO_ 2420113487 OvalRearRightReq: 8 Vector__XXX
CM_ BO_ 2420113487 "Signal reference struct: OvalLightReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 127; original CAN ID: 0x1040004F";

BO_ 2420113664 DoorStatusMsg: 8 Vector__XXX
CM_ BO_ 2420113664 "Signal reference struct: DoorStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 284; original CAN ID: 0x10400100";

BO_ 2420113671 DoorReqMsg: 8 Vector__XXX
CM_ BO_ 2420113671 "Signal reference struct: DoorReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 143; original CAN ID: 0x10400107";

BO_ 2420113921 StepReqMsg: 8 Vector__XXX
CM_ BO_ 2420113921 "Signal reference struct: StepReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 409; original CAN ID: 0x10400201";

BO_ 2420113928 StepStatusMsg: 8 Vector__XXX
CM_ BO_ 2420113928 "Signal reference struct: StepStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 425; original CAN ID: 0x10400208";

BO_ 2422210560 FootReqMsg: 8 Vector__XXX
CM_ BO_ 2422210560 "Signal reference struct: FootReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 158; original CAN ID: 0x10600000";

BO_ 2422210576 Foot1Status: 5 Vector__XXX
CM_ BO_ 2422210576 "Signal reference struct: Foot1Status_t; source header: dbc_CAN_peripheral.h; source line: 344; original CAN ID: 0x10600010";

BO_ 2422210592 Foot2Status: 7 Vector__XXX
CM_ BO_ 2422210592 "Signal reference struct: Foot2Status_t; source header: dbc_CAN_peripheral.h; source line: 374; original CAN ID: 0x10600020";

BO_ 2423259136 Wiper1ReqMsg: 8 Vector__XXX
CM_ BO_ 2423259136 "Signal reference struct: WiperMsg_t; source header: dbc_CAN_peripheral.h; source line: 469; original CAN ID: 0x10700000";

BO_ 2423259151 Wiper1StatusMsg: 8 Vector__XXX
CM_ BO_ 2423259151 "Signal reference struct: WiperMsg_t; source header: dbc_CAN_peripheral.h; source line: 470; original CAN ID: 0x1070000F";

BO_ 2423259152 Wiper2ReqMsg: 8 Vector__XXX
CM_ BO_ 2423259152 "Signal reference struct: WiperMsg_t; source header: dbc_CAN_peripheral.h; source line: 471; original CAN ID: 0x10700010";

BO_ 2423259167 Wiper2StatusMsg: 8 Vector__XXX
CM_ BO_ 2423259167 "Signal reference struct: WiperMsg_t; source header: dbc_CAN_peripheral.h; source line: 472; original CAN ID: 0x1070001F";

BO_ 2424501748 BMSStatusMsg1: 8 Vector__XXX
CM_ BO_ 2424501748 "Signal reference struct: BMSStatusMsg1_t; source header: dbc_CAN_peripheral.h; source line: 498; original CAN ID: 0x1082F5F4";

BO_ 2424567284 BMSStatusMsg2: 8 Vector__XXX
CM_ BO_ 2424567284 "Signal reference struct: BMSStatusMsg2_t; source header: dbc_CAN_peripheral.h; source line: 547; original CAN ID: 0x1083F5F4";

BO_ 2424632820 BMSStatusMsg3: 8 Vector__XXX
CM_ BO_ 2424632820 "Signal reference struct: BMSStatusMsg3_t; source header: dbc_CAN_peripheral.h; source line: 600; original CAN ID: 0x1084F5F4";

BO_ 2424698356 BMSStatusMsg4: 8 Vector__XXX
CM_ BO_ 2424698356 "Signal reference struct: BMSStatusMsg4_t; source header: dbc_CAN_peripheral.h; source line: 650; original CAN ID: 0x1085F5F4";

BO_ 2424763892 BMSStatusMsg5: 8 Vector__XXX
CM_ BO_ 2424763892 "Signal reference struct: BMSStatusMsg5_t; source header: dbc_CAN_peripheral.h; source line: 714; original CAN ID: 0x1086F5F4";

BO_ 2424829428 BMSStatusMsg6: 8 Vector__XXX
CM_ BO_ 2424829428 "Signal reference struct: BMSStatusMsg6_t; source header: dbc_CAN_peripheral.h; source line: 764; original CAN ID: 0x1087F5F4";

BO_ 2424894964 BMSStatusMsg7: 8 Vector__XXX
CM_ BO_ 2424894964 "Signal reference struct: BMSStatusMsg7_t; source header: dbc_CAN_peripheral.h; source line: 810; original CAN ID: 0x1088F5F4";

BO_ 2424960500 BMSStatusMsg8: 8 Vector__XXX
CM_ BO_ 2424960500 "Signal reference struct: BMSStatusMsg8_t; source header: dbc_CAN_peripheral.h; source line: 856; original CAN ID: 0x1089F5F4";

BO_ 2550588916 BMS2ChargerReqMsg: 8 Vector__XXX
CM_ BO_ 2550588916 "Signal reference struct: BMS2ChargerReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 968; original CAN ID: 0x1806E5F4";

BO_ 2553649700 BmsLotteLandmark6: 8 Vector__XXX
CM_ BO_ 2553649700 "Signal reference struct: BmsLotteLandmark6_t; source header: dbc_CAN_peripheral.h; source line: 1460; original CAN ID: 0x18359A24";

BO_ 2553715236 BmsLotteLandmark7: 8 Vector__XXX
CM_ BO_ 2553715236 "Signal reference struct: BmsLotteLandmark7_t; source header: dbc_CAN_peripheral.h; source line: 1518; original CAN ID: 0x18369A24";

BO_ 2553780772 BmsLotteLandmark8: 8 Vector__XXX
CM_ BO_ 2553780772 "Signal reference struct: BmsLotteLandmark8_t; source header: dbc_CAN_peripheral.h; source line: 1573; original CAN ID: 0x18379A24";

BO_ 2565160996 BmsLotteChargerInfo: 8 Vector__XXX
CM_ BO_ 2565160996 "Signal reference struct: BmsLotteChargerInfo_t; source header: dbc_CAN_peripheral.h; source line: 1421; original CAN ID: 0x18E54024";

BO_ 2566197540 BmsLotteDrive1: 8 Vector__XXX
CM_ BO_ 2566197540 "Signal reference struct: BmsLotteDrive1_t; source header: dbc_CAN_peripheral.h; source line: 1264; original CAN ID: 0x18F51124";

BO_ 2566201892 BmsLotteDrive2: 8 Vector__XXX
CM_ BO_ 2566201892 "Signal reference struct: BmsLotteDrive2_t; source header: dbc_CAN_peripheral.h; source line: 1299; original CAN ID: 0x18F52224";

BO_ 2566206244 BmsLotteDrive3: 8 Vector__XXX
CM_ BO_ 2566206244 "Signal reference struct: BmsLotteDrive3_t; source header: dbc_CAN_peripheral.h; source line: 1337; original CAN ID: 0x18F53324";

BO_ 2566747428 BmsLotteChargeVehicle: 8 Vector__XXX
CM_ BO_ 2566747428 "Signal reference struct: BmsLotteChargeVehicle_t; source header: dbc_CAN_peripheral.h; source line: 1377; original CAN ID: 0x18FD7524";

BO_ 2566866420 AirConReqMsg: 8 Vector__XXX
CM_ BO_ 2566866420 "Signal reference struct: AirConReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 171; original CAN ID: 0x18FF45F4";

BO_ 2566869221 ChargerStatusMsg: 8 Vector__XXX
CM_ BO_ 2566869221 "Signal reference struct: ChargerStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 1005; original CAN ID: 0x18FF50E5";

BO_ 2566897978 AirConStatusMsg: 8 Vector__XXX
CM_ BO_ 2566897978 "Signal reference struct: AirConStatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 1056; original CAN ID: 0x18FFC13A";

BO_ 2566897979 AirConVersionMsg: 8 Vector__XXX
CM_ BO_ 2566897979 "Signal reference struct: AirConVersionMsg_t; source header: dbc_CAN_peripheral.h; source line: 1087; original CAN ID: 0x18FFC13B";

BO_ 2566897980 AirConJJK161StatusMsg: 8 Vector__XXX
CM_ BO_ 2566897980 "Signal reference struct: AirConJJK161StatusMsg_t; source header: dbc_CAN_peripheral.h; source line: 1102; original CAN ID: 0x18FFC13C";

BO_ 2566914064 Signal1Debug: 8 Vector__XXX
CM_ BO_ 2566914064 "Signal reference struct: SignalDebugMsg_t; source header: dbc_CAN_peripheral.h; source line: 1169; original CAN ID: 0x19000010";

BO_ 2566914080 Signal2Debug: 8 Vector__XXX
CM_ BO_ 2566914080 "Signal reference struct: SignalDebugMsg_t; source header: dbc_CAN_peripheral.h; source line: 1170; original CAN ID: 0x19000020";

BO_ 2600472576 DTGSpeedRpmMsg: 8 Vector__XXX
CM_ BO_ 2600472576 "Signal reference struct: DTGSpeedRpmMsg_t; source header: dbc_CAN_peripheral.h; source line: 230; original CAN ID: 0x1B001000";

BO_ 2600472592 DTGBrakeInfoMsg: 8 Vector__XXX
CM_ BO_ 2600472592 "Signal reference struct: DTGBrakeInfoMsg_t; source header: dbc_CAN_peripheral.h; source line: 254; original CAN ID: 0x1B001010";

BO_ 2633171444 BMSStatusMsg11: 8 Vector__XXX
CM_ BO_ 2633171444 "Signal reference struct: BMSStatusMsg11_t; source header: dbc_CAN_peripheral.h; source line: 908; original CAN ID: 0x1CF301F4";

BO_ 2633171700 BMSStatusMsg12: 8 Vector__XXX
CM_ BO_ 2633171700 "Signal reference struct: BMSStatusMsg12_t; source header: dbc_CAN_peripheral.h; source line: 922; original CAN ID: 0x1CF302F4";

BO_ 2633171956 BMSChargingCurrent: 8 Vector__XXX
CM_ BO_ 2633171956 "Signal reference struct: BMSChargingCurrent_t; source header: dbc_CAN_peripheral.h; source line: 1665; original CAN ID: 0x1CF303F4";

BO_ 2633172212 BMSChargingCurrentReply: 8 Vector__XXX
CM_ BO_ 2633172212 "Signal reference struct: BMSChargingCurrentReply_t; source header: dbc_CAN_peripheral.h; source line: 1681; original CAN ID: 0x1CF304F4";

BO_ 2634023168 PeripheralVersionReqMsg: 8 Vector__XXX
CM_ BO_ 2634023168 "Signal reference struct: PeripheralVersionReqMsg_t; source header: dbc_CAN_peripheral.h; source line: 272; original CAN ID: 0x1D000100";

BO_ 2634023169 PeripheralVersionMsg: 8 Vector__XXX
CM_ BO_ 2634023169 "Signal reference struct: PeripheralVersionRespMsg_t; source header: dbc_CAN_peripheral.h; source line: 1197; original CAN ID: 0x1D000101";

BO_ 2634023170 PeripheralBootVerMsg: 8 Vector__XXX
CM_ BO_ 2634023170 "Signal reference struct: PeripheralVersionRespMsg_t; source header: dbc_CAN_peripheral.h; source line: 1198; original CAN ID: 0x1D000102";

BO_ 2634023171 PeripheralOcanDBCVerMsg: 8 Vector__XXX
CM_ BO_ 2634023171 "Signal reference struct: PeripheralVersionRespMsg_t; source header: dbc_CAN_peripheral.h; source line: 1199; original CAN ID: 0x1D000103";

BO_ 2634023172 PeripheralPcanDBCVerMsg: 8 Vector__XXX
CM_ BO_ 2634023172 "Signal reference struct: PeripheralVersionRespMsg_t; source header: dbc_CAN_peripheral.h; source line: 1200; original CAN ID: 0x1D000104";

BO_ 2667577344 Recovery: 1 Vector__XXX
CM_ BO_ 2667577344 "Signal reference struct: Recovery_t; source header: dbc_CAN_peripheral.h; source line: 1653; original CAN ID: 0x1F000000";
